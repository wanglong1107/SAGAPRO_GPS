# Keil uVision project RTK_ROVER_RTOS_NEW .uvprojx, settings and files
target RTK_ROVER_RTOS_NEW (6100001::V6.10.1::.\ARMCLANG)
  device: ATSAMC21G18A Microchip
  pack: Keil.SAM-C_DFP.1.4.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) IROM2(0x00400000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: atsamc21Proj +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Objects\atsamc21Proj.bin .\Objects\atsamc21Proj.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 wLevel=3
  c include: .\;..\;.\Device_Startup;.\Module;.\libraries;.\KeilProj\;.\KeilProj\CMSIS\Include;.\KeilProj\config;.\KeilProj\CMSIS\Core\Include;.\KeilProj\samc21\Include;.\KeilProj\samc21\Include\component;.\KeilProj\samc21\Include\instance;.\KeilProj\samc21\Include\pio;.\KeilProj\hal\include;.\KeilProj\hal\src;.\KeilProj\hal\utils\include;.\KeilProj\hal\utils\src;.\KeilProj\hpl\core;.\KeilProj\hpl\divas;.\KeilProj\hpl\dmac;.\KeilProj\hpl\gclk;.\KeilProj\hpl\mclk;.\KeilProj\hpl\osc32kctrl;.\KeilProj\hpl\oscctrl;.\KeilProj\hpl\pm;.\KeilProj\hpl\port;.\KeilProj\hpl\srcom;.\KeilProj\hpl\tc;.\KeilProj\hpl\can;.\KeilProj\hri;.\KeilProj\examples;.\KeilProj\thirdparty\RTOS;.\KeilProj\thirdparty\RTOS\freertos\FreeRTOSV10.0.0;.\KeilProj\thirdparty\RTOS\freertos\FreeRTOSV10.0.0\Source;.\KeilProj\thirdparty\RTOS\freertos\FreeRTOSV10.0.0\Source\include;.\KeilProj\thirdparty\RTOS\freertos\FreeRTOSV10.0.0\Source\portable\GCC\ARM_CM0;.\UserAPP;.\KeilProj\hpl\can
  memory RVCT4: ROM 0x10000 size 0x30000
  memory RVCT5: ROM 0x400000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group UserAPP
    ./UserAPP/: main.cpp jump.c
  group Device_Startup
    ./Device_Startup/: startup_SAMC21.s system_samc21.c
  group driver_init
    ./KeilProj/: atmel_start.c atmel_start.h atmel_start_pins.h driver_init.c driver_init.h rtos_start.c rtos_start.h
  group Config
    ./KeilProj/config/: hpl_divas_config.h hpl_dmac_config.h hpl_gclk_config.h hpl_mclk_config.h hpl_osc32kctrl_config.h hpl_oscctrl_config.h hpl_port_config.h hpl_sercom_config.h hpl_tc_config.h peripheral_clk_config.h FreeRTOSConfig.h hpl_can_config.h
  group hal
    ./KeilProj/hal/include/: hpl_dma.h hal_atomic.h hal_delay.h hal_gpio.h hal_init.h hal_io.h hal_sleep.h hal_timer.h hpl_core.h hpl_delay.h hpl_div.h hpl_gpio.h hpl_i2c_m_async.h hpl_i2c_m_sync.h hpl_i2c_s_async.h hpl_i2c_s_sync.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_pwm.h hpl_reset.h hpl_sleep.h hpl_spi.h hpl_spi_async.h hpl_spi_m_async.h hpl_spi_m_dma.h hpl_spi_m_sync.h hpl_spi_s_async.h hpl_spi_s_sync.h hpl_spi_sync.h hpl_timer.h hpl_usart.h hpl_usart_async.h hpl_usart_sync.h hal_usart_async.h hal_i2c_m_sync.h hal_can_async.h hpl_can.h hpl_can_async.h hal_flash.h hpl_flash.h
    ./KeilProj/hal/src/: hal_atomic.c hal_delay.c hal_gpio.c hal_init.c hal_io.c hal_sleep.c hal_timer.c hal_usart_async.c hal_i2c_m_sync.c hal_can_async.c hal_flash.c
    ./KeilProj/hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_event.h utils_increment_macro.h utils_list.h utils_repeat_macro.h utils_ringbuffer.h
    ./KeilProj/hal/utils/src/: utils_assert.c utils_event.c utils_list.c utils_ringbuffer.c
  group hpl
    ./KeilProj/hpl/core/: hpl_core_m0plus_base.c hpl_core_port.h hpl_init.c
    ./KeilProj/hpl/divas/: hpl_divas.c
    ./KeilProj/hpl/dmac/: hpl_dmac.c
    ./KeilProj/hpl/gclk/: hpl_gclk.c hpl_gclk_base.h
    ./KeilProj/hpl/mclk/: hpl_mclk.c
    ./KeilProj/hpl/osc32kctrl/: hpl_osc32kctrl.c
    ./KeilProj/hpl/oscctrl/: hpl_oscctrl.c
    ./KeilProj/hpl/pm/: hpl_pm.c hpl_pm_base.h
    ./KeilProj/hpl/port/: hpl_gpio_base.h
    ./KeilProj/hpl/sercom/: hpl_sercom.c
    ./KeilProj/hpl/tc/: hpl_tc.c hpl_tc_base.h
    ./KeilProj/hpl/can/: hpl_can.c hpl_can_base.h
    ./KeilProj/hpl/nvmctrl/: hpl_nvmctrl.c
  group hri
    ./KeilProj/hri/: hri_ac_c21.h hri_adc_c21.h hri_c21.h hri_can_c21.h hri_ccl_c21.h hri_dac_c21.h hri_divas_c21.h hri_dmac_c21.h hri_dsu_c21.h hri_eic_c21.h hri_evsys_c21.h hri_gclk_c21.h hri_hmatrixb_c21.h hri_freqm_c21.h hri_mclk_c21.h hri_mpu_c21.h hri_mtb_c21.h hri_nvic_c21.h hri_nvmctrl_c21.h hri_osc32kctrl_c21.h hri_oscctrl_c21.h hri_pac_c21.h hri_pm_c21.h hri_port_c21.h hri_rstc_c21.h hri_rtc_c21.h hri_sdadc_c21.h hri_sercom_c21.h hri_supc_c21.h hri_systemcontrol_c21.h hri_systick_c21.h hri_tc_c21.h hri_tcc_c21.h hri_tsens_c21.h hri_wdt_c21.h
  group examples
    ./KeilProj/examples/: driver_examples.c driver_examples.h
  group AP_HAL
    ./libraries/AP_HAL/utility/: RingBuffer.cpp RingBuffer.h
    ./libraries/AP_HAL/: AP_HAL.h I2CDevice.h
  group hal_drivers
    ./hal_drivers/: drv_gpio.cpp drv_gpio.h hal_uart.cpp hal_uart.h drv_hrt.c drv_hrt.h hal_i2c.cpp hal_i2c.h hal_can.cpp hal_can.h
  group freeRTOS
    ./KeilProj/thirdparty/RTOS/: hal_rtos.h
    ./KeilProj/thirdparty/RTOS/freertos/FreeRTOSV10.0.0/: rtos_port.c rtos_port.h
    ./KeilProj/thirdparty/RTOS/freertos/FreeRTOSV10.0.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./KeilProj/thirdparty/RTOS/freertos/FreeRTOSV10.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ./KeilProj/thirdparty/RTOS/freertos/FreeRTOSV10.0.0/Source/portable/GCC/ARM_CM0/: port.c portmacro.h
    ./KeilProj/thirdparty/RTOS/freertos/FreeRTOSV10.0.0/Source/portable/MemMang/: heap_4.c
  group Module
    ./Module/: type_conversion.cpp type_conversion.h ublox_F9P.cpp ublox_F9P.h qmc5883.cpp qmc5883.h
  group Filter
    ./libraries/Filter/: LowPassFilter2p.cpp LowPassFilter2p.h
  group AP_Math
    ./libraries/AP_Math/: matrixN.cpp matrixN.h vector2.cpp vector2.h vector3.cpp vector3.h matrix3.cpp matrix3.h AP_Math.cpp AP_Math.h
